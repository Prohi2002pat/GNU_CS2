options:
  parameters:
    author: Rima Thakur
    generate_options: qt_gui
    id: realaudioreceiver
    output_language: python
    title: Real Time Audio Transmitter
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '64000'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '16'
    quad_rate: '1024000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '64000'
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '10'
    type: float
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '1.39264e-20'
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Receiver Spectrum"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Received Time"'
    size: '1024'
    srate: '64000'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: 2.4e9
    clock_rate: 200e6
    gain0: '60'
    samp_rate: '1024000'
    sync: none
    type: fc32
  states: {}

connections:
- [analog_agc_xx_0, '0', analog_wfm_rcv_0, '0']
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_freq_sink_x_0, '0']
- [fir_filter_xxx_0, '0', analog_agc_xx_0, '0']
- [uhd_usrp_source_0, '0', fir_filter_xxx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
