options:
  parameters:
    author: Rima Thakur
    generate_options: qt_gui
    id: realaudiotransmitter
    output_language: python
    title: Real Time Audio Transmitter
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '64000'
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: '64000'
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: '1024000'
    tau: '75e-6'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '64000'
  states: {}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.4'
    type: float
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: '64000'
    fc: '0'
    fftsize: '1024'
    name: '"Audio Frequency"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '64000'
    fc: 3.5e9
    fftsize: '1024'
    name: '"Transmitter Spectrum"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Audio Time"'
    size: '1024'
    srate: '64000'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Transmitter Time Output"'
    size: '1024'
    srate: '64000'
    type: float
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 2.4e9
    gain0: '60'
    samp_rate: '1024000'
    sync: none
    type: fc32
  states: {}

connections:
- [analog_wfm_tx_0, '0', blocks_complex_to_float_1, '0']
- [analog_wfm_tx_0, '0', qtgui_freq_sink_x_1_0, '0']
- [analog_wfm_tx_0, '0', uhd_usrp_sink_0, '0']
- [audio_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [audio_source_0, '0', qtgui_freq_sink_x_1, '0']
- [audio_source_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_float_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_wfm_tx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
